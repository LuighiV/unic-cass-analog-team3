v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sg13g2_IOPadVSS.sym} 180 -320 0 0 {name=x1}
C {sg13g2_IOPadVdd.sym} 180 -210 0 0 {name=x2}
C {sg13g2_IOPadAnalog.sym} 180 -100 0 0 {name=x3}
C {lab_pin.sym} 60 -350 0 0 {name=p1 lab=iovdd}
C {lab_pin.sym} 60 -340 0 0 {name=p2 lab=vss}
C {lab_pin.sym} 60 -300 0 0 {name=p3 lab=vss}
C {lab_pin.sym} 60 -290 0 0 {name=p4 lab=vdd}
C {lab_pin.sym} 60 -240 0 0 {name=p5 lab=iovdd}
C {lab_pin.sym} 60 -230 0 0 {name=p6 lab=vss}
C {lab_pin.sym} 60 -190 0 0 {name=p7 lab=vss}
C {lab_pin.sym} 60 -180 0 0 {name=p8 lab=vdd}
C {lab_pin.sym} 60 -130 0 0 {name=p9 lab=iovdd}
C {lab_pin.sym} 60 -120 0 0 {name=p10 lab=vss}
C {lab_pin.sym} 60 -100 0 0 {name=p11 lab=padres}
C {lab_pin.sym} 60 -80 0 0 {name=p12 lab=vss}
C {lab_pin.sym} 60 -70 0 0 {name=p13 lab=vdd}
C {lab_pin.sym} 300 -100 0 1 {name=p14 lab=pad}
C {iopin.sym} -110 -340 0 0 {name=p15 lab=vdd
}
C {iopin.sym} -110 -320 0 0 {name=p16 lab=vss
}
C {iopin.sym} -100 -100 0 0 {name=p17 lab=padres
}
C {iopin.sym} 390 -100 0 0 {name=p18 lab=pad
}
